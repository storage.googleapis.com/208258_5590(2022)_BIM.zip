Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-08-23T00:54:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 23 00:54:05 2022 * Host: DESKTOP-7H9OEIG * Database: C:\Users\Vlad\AppData\Local\Temp\{F13526A3-C8AB-414D-8E92-BBBC77D2939C}\ifc * Database version: 5507 * Database creation date: Tue Aug 23 00:54:03 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 23 00:54:03 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 23 00:54:03 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 5590 Shower set, 5590(2022):5590 Shower set:343357
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions - NominalDepth: 129.3 mm; NominalHeight: 1151.7 mm; NominalWidth: 98.9 mm
Type - General - Author: BIMStone; BIMObjectName: 5590(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_79; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/08/2022
Type - Green Building Properties - EAN Number: 6414150100420; EN Standard: EN 1112, EN 1113; ETIM Class Number: EC010109 Sliding rod combination; LVI Number: 6510295; NRF Number: 4205443; RSK Number: 8320000; Sales Package dimensions (LxWxH): 1250 x 145 x 30; UNSPSC Class Number: 30181503 Showers; URL Declaration of Conformity: http://static.oras.com/DoC/5590; URL REACH: http://static.oras.com/doc/reach; VVS Number: 737599310
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/5590; 3D View: https://static.oras.com/3D/5590; Catalog Drawing URL: http://static.oras.com/catdrw/5590; Dimension Drawing URL: http://static.oras.com/dimdrw/5590; FDV Document URL: http://www.oras.com/datasheet/5590/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5590; Group: Shower set; Installation and Maintenance Guide URL: http://static.oras.com/manual/5590; Interactive AR View URL: https://static.oras.com/AR/5590; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/5590; Model: 5590 Shower set; Name_en: 5590 Shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 5590; Product Family: Oras Medipro; Product Image URL: http://static.oras.com/image/5590; Product URL: http://static.oras.com/5590; Technical DataSheet URL: http://www.oras.com/datasheet/5590/en; Type Name: 5590 Shower set; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Flexible length / can be shortened; Connection Size: G1/2; DN Size: 18 mm; Flow Rate At 300kPa With Flow Controller: 0.000706293 m3/s; Hand Shower Size: Ø 95 mm; Installation Type: Wall mounted; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: Litter filter(s); Shower Parts: Hand shower;Shower rail;Adjustable shower rail bracket;Shower hose (1750 mm);Rotatable ball joint connection;Anti limescale technology (easy to clean); Shower Spray: Low aerosol; Shower Spray Number: 1 shower spray; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5590(2022); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5590; Name: 5590 Shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 130 x 100 x 1150 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.275081 m2; Volume: 0.0146713 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 5590(2022): 5590 Shower set; Family and Type: 5590(2022): 5590 Shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5590(2022): 5590 Shower set; Type Id: 5590(2022): 5590 Shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
